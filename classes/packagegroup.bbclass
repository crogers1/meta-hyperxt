# This class is required by meta-qt5, but isn't yet in mainline OpenXT.
inherit task
