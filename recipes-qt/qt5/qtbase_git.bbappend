PACKAGECONFIG[libinput] = ""
